FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-Quectel-EC25-USB-Serial-Driver-Support.patch"

